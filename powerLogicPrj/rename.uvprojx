# Keil uVision project rename.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test1 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_SEER_ASSERT,USE_MINI_PRINT
  c misc: --cpp
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Libraries\startup;..\iap;..\Logger;.\USER;..\F1HAL;..\utility;..\SPIDriver;..\..\RTT;..\powerLogicPrj
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: stm32f10x_it.c main.cpp logic_out.c key_monitor.c power_state_recoder_manager.c power_process.c exti_monitor.cpp
  group Module
    ./: PowerManager.h PowerManager.cpp PdoManager.h PdoManager.cpp LedManager.h LedManager.cpp BrakeManager.h BrakeManager.cpp adcManager.h adcManager.cpp
  group CMSIS
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
  group Liberaries
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_adc.c
  group startup
    ../Libraries/startup/: startup_stm32f10x_hd.s
  group HAL
    ../F1HAL/: Timer.cpp HeartLed.c CommonConfig.c CUsart.cpp stmflashV2.cpp
  group spi
    ../SPIDriver/: spi.c
  group rtt
    ../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
