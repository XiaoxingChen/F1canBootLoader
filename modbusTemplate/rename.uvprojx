# Keil uVision project rename.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test1 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4
  c define: USE_MINI_PRINT
  c misc: --cpp
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Libraries\startup;..\iap;..\Logger;..\utility;.\USER;..\F1HAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: CommonConfig.c stm32f10x_it.c main.cpp powerupOption.cpp HeartLed.c
  group CMSIS
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
  group Liberaries
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_flash.c
  group startup
    ../Libraries/startup/: startup_stm32f10x_hd.s
  group Logger
    ../Logger/: rtt_vsnprintf.c Console.cpp SEGGER_RTT.c
  group HAL
    ../F1HAL/: CUsart.cpp Timer.cpp stmflash.c
